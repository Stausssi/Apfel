# Keil uVision project Apfel.uvproj, settings and files
target Target (MCS-51)
  device: C517A-L Infineon
  cpu: IRAM(0-0xFF) CLOCK(24000000) MOD517DP MOD517AU XRAM(0xF800-0xFFFF)
  output: Apfel
  c flags: Optimize=8 SizeSpeed=1
  group Source
    $TC_ROOT$/../../../Users/Simon/OneDrive - Hochschule/Programmieren/Assembler/Sys. Prog/Projekt/Apfel/: main.a51
